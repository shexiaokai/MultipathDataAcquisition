# Keil uVision project MultipathDataAcquisition.uvprojx, settings and files
target MultipathDataAcquisition (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MultipathDataAcquisition
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Header;..\Bsp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: Main.c
  group Header
    ../Bsp/: stm32f0xx.h
  group Bsp
    ../Bsp/: system_stm32f0xx.c system_stm32f0xx.h core_cm0.h startup_stm32f030.s
